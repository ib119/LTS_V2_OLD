OnlyResistors

R1 0 1 1
R2 1 2 2
R3 2 3 3
r4 3 0 4
